# Keil uVision project MY_H750ATK_Demo.uvprojx, settings and files
target MY_H750ATK_Demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: MY_H750ATK_Demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx,ARM_MATH_LOOPUNROLL,ARM_MATH_ROUNDING,ARM_MATH_MATRIX_CHECK
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/delay;../Drivers/BSP/LCD;../Drivers/BSP/MPU;../Drivers/BSP/SDRAM;../Drivers/BSP/TOUCH;../Drivers/BSP/24CXX;../Drivers/BSP/IIC;../Drivers/BSP/MY;../MDK-ARM;../Drivers/BSP/KEY
  library: MicroLIB
  memory RVCT1: ROM 0x90000000 size 0x800000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma2d.c fmc.c ltdc.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_sram.c stm32h7xx_hal_qspi.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group BSP
    ../Drivers/BSP/delay/: delay.c
    ../Drivers/BSP/LCD/: lcd.c myltdc.c
    ../Drivers/BSP/MPU/: mpu.c
    ../Drivers/BSP/SDRAM/: sdram.c
    ../Drivers/BSP/TOUCH/: ctiic.c ft5206.c gt9xxx.c touch.c
    ../Drivers/BSP/24CXX/: 24cxx.c
    ../Drivers/BSP/IIC/: myiic.c
    ../Drivers/BSP/KEY/: key.c
  group MY
    ../Drivers/BSP/MY/: Minor_function.c MY_ADC.c
    ./: MY_USART.c MY_USART.h
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
